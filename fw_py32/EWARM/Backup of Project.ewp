# IAR project Backup of Project.ewp, settings and files
configuration karifa (ARM, debug)
  General.OGChipSelectEditMenu: PY32F003x4 Puya PY32F003x4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; PY32F002Ax5
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Device; ..\Drivers\CMSIS\Include; ..\Drivers\PY32F0xx_HAL_Driver\Inc; ..\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f002ax5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/iar/: startup_py32f002axx.s
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_adc.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_tim.c py32f0xx_ll_utils.c
  group Src
    ../Src/: animation.c animation.h batterylevel.c batterylevel.h config.h led.c led.h led_switching.c main.c main.h persist.c persist.h platform.h py32_assert.h py32f0xx_it.c py32f0xx_it.h rgbled.c rgbled.h system_py32f0xx.c types.h util.c util.h
